Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 0f80a12e-7679-4fb9-98b3-aeacaee4e7f1, NumberOfSaves: 1]
File name: 0001
Time: 2024-03-20T08:07:07+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12481660_USA_KM7020FR:26702010_USA_12481660_KM7020FR, (2)
In: Default
Type - Material: z_Miele_Design_Stainless Steel, z_Miele_Design_Glass Black, <Unnamed>, Default, z_Miele_Connection_Electric, z_Miele_Design_CLST
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: 26702010_USA_12481660_KM7020FR; sets with these values: 2
